# Keil uVision project ROV.uvprojx, settings and files
target ROV (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: ROV +hex
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_HAL_DRIVER,STM32H743xx,ARM_MATH_CM7,__CC_ARM,__FPU_USED=1U,__FPU_PRESENT=1,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Inc;                                       ../Drivers/STM32H7xx_HAL_Driver/Inc;                                       ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;                                       ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                                       ../Drivers/CMSIS/Include;                                       ..\application;                                       ..\bsp;                                       ..\components\devices;                                       ..\components;                                       ..\components\suport;                                       ..\application\protocol;                                       ../Middlewares/Third_Party/FreeRTOS/Source/include;                                       ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                       ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                       ../Middlewares/Third_Party/LwIP/src/include;                                       ../Middlewares/Third_Party/LwIP/system;                                       ../Drivers/BSP/Components/lan8742;                                       ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;                                       ../Middlewares/Third_Party/LwIP/src/include/lwip;                                       ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;                                       ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;                                       ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;                                       ../Middlewares/Third_Party/LwIP/src/include/netif;                                       ../Middlewares/Third_Party/LwIP/src/include/posix;                                       ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                                       ../Middlewares/Third_Party/LwIP/system/arch;                                       ..\components\controller;                                       ..\components\algorithm
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group applications
    ../application/: IMU_receive.c water_level_task.c tem_hum_task.c depth_meter_receive.c altimeter_receive.c comunication.c socket_send.c socket_receive.c parse_task.c pwm_task.c thruster.c rov_movation_task.c rov_behaviour.c detect_task.c debug_info.c
  group boards
    ../bsp/: bsp_adc.c bsp_can.c bsp_i2c.c bsp_crc32.c bsp_usart.c bsp_dac.c bsp_pulse.c bsp_pwm.c bsp_init.c
  group devices
    ../components/devices/: OLED.c sth31driver.c
  group Application/User
    ../Src/: main.c gpio.c adc.c crc.c dac.c debug.c dma.c fdcan.c freertos.c i2c.c lwip.c ethernetif.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group support
    ../components/suport/: CRC8_CRC16.c fifo.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group controller
    ../components/controller/: pid.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lan8742/: lan8742.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group algorithm
    ../components/algorithm/: user_lib.c arm_cortexM7lfdp_math.lib
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
